# Repository OceanChen1023/ESP32_ForceSensor

File README.md:

# **Adafruit ESP32 feather無線壓力感測器傳輸系統**

## 摘要 
使用兩塊ESP32，其中一塊做為8個力感測器資料接收端並透過WIFI發送到另一塊ESP32，ESP32接收端同時透過Micro-ROS將力感測器資料傳送至ROS2系統當中，經測試力感測器資料接收頻率約62Hz，符合設計要求。

## Github檔案內容簡述
ESP32_Transmiiter: ESP32發送端

ESP32_Receiver: ESP32接收端

ESP32_Read_Mac_Address: 因使用MAC Address方式傳輸，需要先讀取接收端MAC Address，後發送端設定

Press_Sensor_Layout: 電路設計圖以及PCB Layout

## 系統環境架設

**Material Request:**
1. Adafruit EPS32 feather
2. Micro-USB to USB cable

**Environment:**

1.Ubuntu 22.04 humble

2.Ros2

3.Micro-Ros

5.Arduino IDE

**ROS & ROS2 Env. Establish**
Before install ROS2, must to install ROS first, following the official tutorial [https://docs.ros.org/en/humble/Installation/Ubuntu-Install-Debians.html](https://docs.ros.org/en/humble/Installation/Ubuntu-Install-Debians.html) 

**Arduino IDE Env. Establish**
Step1:Download Arduino IDE from official website [https://www.arduino.cc/en/software](https://www.arduino.cc/en/software)
Step2:Extract to ./Arduino or any directory you want
Step3:Install ESP32 library(choose "esp32 by Espressif Systems")
Step4:Micro-ROS Library Setting, Following Sketch>>Include Library>>Add zip library>>Choose "micro_ros_arduino-2.0.7-humble" download zip from [https://github.com/micro-ROS/micro_ros_arduino/releases/tag/v2.0.7-humble](https://github.com/micro-ROS/micro_ros_arduino/releases/tag/v2.0.7-humble)

Issue:At beginning, you execute programm maybe show error "No module 'serial'", just keyin command on terminal 
```
pip3 install pyserial
```

**Micro Ros and Arduino IDE establishment, reference this website**
[https://www.hackster.io/514301/micro-ros-on-esp32-using-arduino-ide-1360ca](https://www.hackster.io/514301/micro-ros-on-esp32-using-arduino-ide-1360ca)

Final, When you run ros2 program, you should check your serial comport name, it always is </dev/ttyUSB0> instead of the comport choosen.

```
ros2 run micro_ros_agent micro_ros_agent serial --dev /dev/ttyUSB0
```

If ROS2 don't dectect your serial comport. The second command should restart OS and it work permanently.
```
sudo chmod 777 /dev/ttyUSB0
sudo usermod -a -G dialout <Your_user_name>
```

## KiCad design Pressure_Sensor_Layout/Pressure_Sensor.kicad_pcb

Parts:
A1: Adafruit_Feather_HUZZAH32_ESP32; Adafruit_Feather
C1: 0.1pf
C2: C
R1, R2, R3, R4, R5, R6, R7, R8: 10k
U1, U2, U3, U4, U5, U7, U8, U9, U10: (no value)
U6: 4051

Connections:
+3.3VA: C2.1, U1.1 (Vref3.3), U2.1 (Vref3.3), U3.1 (Vref3.3), U4.1 (Vref3.3), U7.1 (Vref3.3), U8.1 (Vref3.3), U9.1 (Vref3.3), U10.1 (Vref3.3)
/AN_0: R1.1, U1.2 (Vout), U6.13 (X0)
/AN_1: R2.1, U2.2 (Vout), U6.14 (X1)
/AN_2: R3.1, U3.2 (Vout), U6.15 (X2)
/AN_3: R4.1, U4.2 (Vout), U6.12 (X3)
/AN_4: R5.1, U6.1 (X4), U7.2 (Vout)
/AN_5: R6.1, U6.5 (X5), U8.2 (Vout)
/AN_6: R7.1, U6.2 (X6), U9.2 (Vout)
/AN_7: R8.1, U6.4 (X7), U10.2 (Vout)
/AN_Out: A1.5 (DAC2/A0), U6.3 (X)
/SEL_0: A1.24 (A11/IO12), U6.11 (A)
/SEL_1: A1.25 (A12/IO13), U6.10 (B)
/SEL_2: A1.23 (A10/IO27), U6.9 (C)
/SPI_CS: A1.16 (IO21), U5.1 (CS)
/SPI_MISO: A1.13 (MISO/IO19), U5.4 (MISO)
/SPI_MOSI: A1.12 (MOSI/IO18), U5.3 (MOSI)
/SPI_SCK: A1.11 (SCK/IO5), U5.2 (SCK)
/Vref3.3: A1.2 (3V3), U5.5 (VCC)
GND: A1.4 (GND), C1.2, C2.2, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, U5.6 (GND), U6.6 (Inh), U6.16 (VDD)
unnamed: C1.1, U6.7 (VEE)

Notes on the sheet:
Huzzah32_esp32 電源供應: 1.BAT(4.2/3.7鋰電池) 2.USB Cable(直接插入就好)

Board: 2 copper layers, 21 parts (0 on the bottom side), 20 nets.

## Code that names these connections

File ESP32_Transmitter.ino:

#include <SPI.h>
#include <SD.h>
#include <FS.h>
#include <esp_now.h>
#include <WiFi.h>
#include <time.h>
#include <Arduino.h>
//#include "ESP32Time.h"

//Huzzah32
#define led LED_BUILTIN
#define BD 115200
const int AN_Out =A2;
const int SEL_0 =A12;
const int SEL_1 =A11;
const int SEL_2 =A10;
int AN_Val;
int CH_Val[7];

//SD Card
const int SD_CS =4;
String dataMessage;
String timeMessage;
String tempMSG;

//ESP_NOW
//uint8_t broadcastAddress[] = {0xC4, 0xDD, 0x57, 0x9E, 0xA8, 0x18};  // REPLACE WITH YOUR RECEIVER MAC Address
uint8_t broadcastAddress[] = {0x94, 0xb9, 0x7e, 0x6b, 0x68, 0xd8};  // REPLACE WITH YOUR RECEIVER MAC Address
typedef struct struct_message {
  unsigned long timeStamp;
  int CH_Value[7];
} struct_message;

struct_message myData;

//RTC
//const char* ntpServer="pool.ntp.org";
//const long gmtOffset_sec=8*3600;
//const int dalightOffset_sec=0;

void SD_setup(){
  Serial.println(MOSI);
  Serial.println(MISO);
  Serial.println(SCK);
  Serial.println(SS);

  Serial.begin(BD);
  //Serial.begin(460800);
  SD.begin(4);
  if (!SD.begin(SD_CS)) {
    Serial.println("Card Mount Failed");
    return;
  }
  uint8_t cardType = SD.cardType();
  if (cardType == CARD_NONE) {
    Serial.println("No SD card attached");
    return;
  }
  Serial.println("Initializing SD card...");
  if (!SD.begin(SD_CS)) {
    Serial.println("ERROR - SD card initialization failed!");
    return;    // init failed
  }

  File file = SD.open("/log.txt");
  if (!file) {
    Serial.println("File doens't exist");
    Serial.println("Creating file...");
    writeFile(SD, "/log.txt", "Time , CH1_RAW , CH2_RAW, CH3_RAW, CH4_RAW \r\n");
  }
  else {
    Serial.println("File already exists");
    deleteFile(SD, "/log.txt");
    delay(400);
    writeFile(SD, "/log.txt", "Time , CH1_RAW , CH2_RAW, CH3_RAW, CH4_RAW \r\n");
  }
  file.close();
}

void ESP_Now_setup(){
  WiFi.mode(WIFI_STA);
   // Init ESP-NOW
  if (esp_now_init() != ESP_OK) {
    Serial.println("Error initializing ESP-NOW");
    return;
  }
  esp_now_peer_info_t peerInfo;
  // Register peer
  memset(&peerInfo, 0, sizeof(peerInfo));
  memcpy(peerInfo.peer_addr, broadcastAddress, 6);
  peerInfo.channel = 0;  
  peerInfo.encrypt = false;
 
  //esp_now_register_send_cb(OnDataSent);
  esp_err_t addStatus = esp_now_add_peer(&peerInfo);
   // Add peer        
  if (addStatus == ESP_OK) {
    // Pair success
    Serial.println("Pair success");
  } else if (addStatus == ESP_ERR_ESPNOW_NOT_INIT) {
    // How did we get so far!!
    Serial.println("ESPNOW Not Init");
  } else if (addStatus == ESP_ERR_ESPNOW_ARG) {
    Serial.println("Invalid Argument");
  } else if (addStatus == ESP_ERR_ESPNOW_FULL) {
    Serial.println("Peer list full");
  } else if (addStatus == ESP_ERR_ESPNOW_NO_MEM) {
    Serial.println("Out of memory");
  } else if (addStatus == ESP_ERR_ESPNOW_EXIST) {
    Serial.println("Peer Exists");
  } else {
    Serial.println("Not sure what happened");
  }
}

// callback when data is sent
void OnDataSent(const uint8_t *mac_addr, esp_now_send_status_t status) {
  Serial.print("\r\nLast Packet Send Status:\t");
  Serial.println(status == ESP_NOW_SEND_SUCCESS ? "Delivery Success" : "Delivery Fail");
}

int64_t xx_time_get_time() {
	struct timeval tv;
	gettimeofday(&tv, NULL);
	return (tv.tv_sec * 1000LL + (tv.tv_usec / 1000LL));
}

void printLocalTime(){
  struct tm timeinfo;
  if(!getLocalTime(&timeinfo)){
    Serial.println("Failed to obtain time");
    return;
  }
  Serial.println(&timeinfo,"%A,%B %d %Y %H:%M:%S");
}

int64_t gettime(){
  struct timeval tv_now;
  gettimeofday(&tv_now, NULL);
  int64_t time_us = (int64_t)tv_now.tv_sec * 1000000L + (int64_t)tv_now.tv_usec;
}

int64_t getTime_Test(){
  struct timeval tv;
  gettimeofday(&tv, NULL);
  int64_t time_us = tv.tv_usec;
}

void logSDCard() {
  unsigned long currentTime=millis();
  myData.timeStamp=currentTime;
  dataMessage = String(currentTime) + "," +
                String(myData.CH_Value[0]) + ", " + String(myData.CH_Value[1]) + ", " +
                String(myData.CH_Value[2]) + ", " + String(myData.CH_Value[3]) + ", " +
                String(myData.CH_Value[4]) + ", " + String(myData.CH_Value[5]) + ", " +
                String(myData.CH_Value[6]) + ", " + String(myData.CH_Value[7]) +"\r\n";
  Serial.print("Save data: ");
  Serial.println(dataMessage);
  appendFile(SD, "/log.txt", dataMessage.c_str());
}

// Write to the SD card (DON'T MODIFY THIS FUNCTION)
void writeFile(fs::FS &fs, const char * path, const char * message) {
  Serial.printf("Writing file: %s\n", path);

  File file = fs.open(path, FILE_WRITE);
  if (!file) {
    Serial.println("Failed to open file for writing");
    return;
  }
  if (file.print(message)) {
    Serial.println("File written");
  } else {
    Serial.println("Write failed");
  }
  file.close();
}

void deleteFile(fs::FS &fs, const char * path){
    Serial.printf("Deleting file: %s\n", path);
    if(fs.remove(path)){
        Serial.println("File deleted");
    } else {
        Serial.println("Delete failed");
    }
}

// Append data to the SD card (DON'T MODIFY THIS FUNCTION)
void appendFile(fs::FS &fs, const char * path, const char * message) {
  Serial.printf("Appending to file: %s\n", path);

  File file = fs.open(path, FILE_APPEND);
  if (!file) {
    Serial.println("Failed to open file for appending");
    return;
  }
  if (file.print(message)) {
    Serial.println("Message appended");
  } else {
    Serial.println("Append failed");
  }
  file.close();
}

void setup() {
  Serial.begin(BD);
  //Serial.begin(460800);
  while (!Serial) {    // 等待串列埠連線
  }

  ESP_Now_setup();
  SD_setup();

  // set LED to be an output pin
  pinMode(led, OUTPUT);
  pinMode(AN_Out, INPUT);
  pinMode(SEL_0,OUTPUT);
  pinMode(SEL_1,OUTPUT);
  pinMode(SEL_2,OUTPUT);
  init();
}

void init(){
  Serial.print("\nWaiting for SD card ready...");
  digitalWrite(led, HIGH);
  digitalWrite(SEL_0, LOW); 
  digitalWrite(SEL_1, LOW); 
  digitalWrite(SEL_2, LOW);
  delay(5000);                // wait for a half second

}

void SetCH0(){
  //SEL0=0 SEL1=0  Case0
  digitalWrite(SEL_0, LOW); 
  digitalWrite(SEL_1, LOW);  
  digitalWrite(SEL_2, LOW);
  delay(1);
         
}

void SetCH1(){
 //SEL0=1 SEL1=0 Case1
  digitalWrite(SEL_0, HIGH); 
  digitalWrite(SEL_1, LOW);
  digitalWrite(SEL_2, LOW);  
  delay(1);

}

void SetCH2(){
  //SEL0=0 SEL1=1 Case2
  digitalWrite(SEL_0, LOW); 
  digitalWrite(SEL_1, HIGH);
  digitalWrite(SEL_2, LOW);
  delay(1);

}

void SetCH3(){
  //SEL0=1 SEL1=1 Case3
  digitalWrite(SEL_0, HIGH); 
  digitalWrite(SEL_1, HIGH);
  digitalWrite(SEL_2, LOW);
  delay(1);

}

void SetCH4(){
  //SEL0=0 SEL1=0  Case0
  digitalWrite(SEL_0, LOW); 
  digitalWrite(SEL_1, LOW);  
  digitalWrite(SEL_2, HIGH);
  delay(1);
         
}

void SetCH5(){
  //SEL0=0 SEL1=0  Case0
  digitalWrite(SEL_0, HIGH); 
  digitalWrite(SEL_1, LOW);  
  digitalWrite(SEL_2, HIGH);
  delay(1);
         
}

void SetCH6(){
  //SEL0=0 SEL1=0  Case0
  digitalWrite(SEL_0, LOW); 
  digitalWrite(SEL_1, HIGH);  
  digitalWrite(SEL_2, HIGH);
  delay(1);
         
}

void SetCH7(){
  //SEL0=0 SEL1=0  Case0
  digitalWrite(SEL_0, HIGH); 
  digitalWrite(SEL_1, HIGH);  
  digitalWrite(SEL_2, HIGH);
  delay(1);
         
}

void loop() {
  SetCH0();
  AN_Val =analogRead(AN_Out);
  //CH_Val[0]=AN_Val;
  myData.CH_Value[0]=AN_Val;
  
  SetCH1();
  AN_Val =analogRead(AN_Out);
  //CH_Val[1]=AN_Val;
  myData.CH_Value[1]=AN_Val;
   
  SetCH2();
  AN_Val =analogRead(AN_Out);
  //CH_Val[2]=AN_Val;
  myData.CH_Value[2]=AN_Val;
  
  SetCH3();
  AN_Val =analogRead(AN_Out);
  //CH_Val[3]=AN_Val;
  myData.CH_Value[3]=AN_Val;
  
  SetCH4();
  AN_Val =analogRead(AN_Out);
  //CH_Val[3]=AN_Val;
  myData.CH_Value[4]=AN_Val;
  
  SetCH5();
  AN_Val =analogRead(AN_Out);
  //CH_Val[3]=AN_Val;
  myData.CH_Value[5]=AN_Val;
  
  SetCH6();
  AN_Val =analogRead(AN_Out);
  //CH_Val[3]=AN_Val;
  myData.CH_Value[6]=AN_Val;
  
  SetCH7();
  AN_Val =analogRead(AN_Out);
  //CH_Val[3]=AN_Val;
  myData.CH_Value[7]=AN_Val;
  /*
  for(int i=0; i<4; i++){ 
  Serial.print("CH_VAL[");
  Serial.print(i);
  Serial.print("]=");
  Serial.println(CH_Val[i]);
  }
  */
  //printLocalTime();
  logSDCard();
  //Serial.println(AN_Val);   

  
  //strcpy(myData.a, tempMSG.c_str());
  
  
  esp_err_t result = esp_now_send(broadcastAddress, (uint8_t *) &myData, sizeof(myData));
  /*
  if (result == ESP_OK) {
    Serial.println("Sent with success");
  }
  else{
    Serial.println("Error sending the data");
  }
  */

  digitalWrite(led, LOW);    // turn the LED off by making the voltage LOW
  delay(1);                // wait for a half second

}
 

## Commit log

2024-08-01 ESP32_力感測器建立
2024-08-07 ESP32_FroceSensor
2024-08-07 ESP32_ForceSensor_Layout
2024-08-07 last changed at Aug 7, 2024 1:21 PM, pushed by Oceane Chen
2024-11-20 Created using Colab
